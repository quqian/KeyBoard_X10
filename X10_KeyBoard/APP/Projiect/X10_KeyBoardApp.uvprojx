# Keil uVision project X10_KeyBoardApp.uvprojx, settings and files
target X10_KeyBoardApp (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: GD32F350CB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.1.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x04000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: X10_KeyBoard_app +hex
  AfterMake: fromelf --bin --output deal_with_file\App_Bin\X10_KeyBoard_app.bin .\Objects\X10_KeyBoard_app.axf
  AfterMake: ..\Projiect\deal_with_file\aaa.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F350
  c include: ..\Library\Firmware\GD32F3x0_standard_peripheral\Include;..\Src\BSP;..\Src\Application;..\Src;..\Library\Firmware\CMSIS;..\FreeRTOSv10\FreeRTOS\include;..\FreeRTOSv10\CMSIS_RTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../Src/: main.c
    ../Src/Application/: NFCard.c ComProto.c ProtoWithMainBoard.c
  group BSP
    ../Src/BSP/: FIFO.c flash.c system.c usart.c systick.c sc8042b.c fm175xx.c aes.c spi.c m1_card.c sim_uart.c led.c rtc.c tsiKey.c
    ../Src/Application/: flash_usr.c
  group StartUo
    ../Library/Firmware/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ../Library/Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group lib
    ../Library/Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
